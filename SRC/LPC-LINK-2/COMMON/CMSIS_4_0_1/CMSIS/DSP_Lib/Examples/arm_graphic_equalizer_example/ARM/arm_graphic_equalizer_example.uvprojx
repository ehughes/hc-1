# Keil uVision project arm_graphic_equalizer_example.uvprojx, settings and files
target ARMCM0 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.0.11
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1
  c define: ARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: math_helper.c arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c
  group Documentation
    ./: Abstract.txt
  group ::CMSIS
    C:/Keil/ARM/PACK/ARM/CMSIS/4.0.11/CMSIS/Lib/ARM/: arm_cortexM0l_math.lib arm_cortexM3l_math.lib arm_cortexM4lf_math.lib
  group ::Device
    RTE/Device/ARMCM0/: startup_ARMCM0.s system_ARMCM0.c
    RTE/Device/ARMCM3/: startup_ARMCM3.s system_ARMCM3.c
    RTE/Device/ARMCM4/: startup_ARMCM4.s system_ARMCM4.c
target ARMCM3 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.0.11
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(10000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1
  c define: ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM4 (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.0.11
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(10000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1
  c define: ARM_MATH_CM4 __FPU_PRESENT=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1
