# Keil uVision project arm_convolution_example.uvproj, settings and files
target ARMCM0 (ARM-GNU)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.0.13
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: arm_convolution_example
  group Source Files
    ./: arm_convolution_example_f32.c math_helper.c
  group CMSIS Device
    ./Startup/: startup_ARMCM0.S system_ARMCM0.c startup_ARMCM3.S system_ARMCM3.c startup_ARMCM4.S system_ARMCM4.c
target ARMCM3 (ARM-GNU)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.0.13
  cpu: CPUTYPE("Cortex-M3") CLOCK(10000000) ESEL ELITTLE
  output: arm_convolution_example
target ARMCM4 (ARM-GNU)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.0.13
  cpu: CPUTYPE("Cortex-M4") FPU2 CLOCK(10000000) ESEL ELITTLE
  output: arm_convolution_example
